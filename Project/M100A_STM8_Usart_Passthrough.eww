<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\M100A_STM8_Usart_Passthrough.ewp</path>
  </project>
  <batchBuild/>
</workspace>


