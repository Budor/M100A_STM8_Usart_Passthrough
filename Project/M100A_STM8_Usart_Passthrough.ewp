# IAR project M100A_STM8_Usart_Passthrough.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_HD; USE_PABOOST
  ICCSTM8.CCIncludePath2: ..\USER\BOARDS\MCU\STM8\STM8L15x_StdPeriph_Driver\inc; ..\USER\BOARDS\MCU\STM8; ..\USER\SYSTEM; ..\USER\RADIO; ..\USER\RADIO\SX1276; ..\USER\BOARDS\M100A; ..\USER\APPS\M100A
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: M100A_STM8_Usart_Passthrough.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: M100A_STM8_Usart_Passthrough.hex
  group apps
    ../User/apps/M100A/: main.c
  group boards\M100A
    ../User/boards/M100A/: board.c crc16.c gpio-board.c m100a-board.c spi-board.c stm8l_eeprom.c sx1276-board.c timer-board.c uart-board.c
  group boards\M100A\STM8L1xx_StdPeriph_Driver
    ../User/boards/mcu/stm8/STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_usart.c stm8l15x_wfe.c
  group boards\mcu\stm8
    ../User/boards/mcu/stm8/: stm8l15x_it.c utilities.c
  group radio
    ../User/radio/sx1276/: sx1276.c
  group system
    ../User/system/: delay.c fifo.c gpio.c timer.c uart.c
